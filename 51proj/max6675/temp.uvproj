# Keil uVision project temp.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temp +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\max6675
  group Source Group 1
    ./: max6675.c main.c tm1637.c
