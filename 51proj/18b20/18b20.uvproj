# Keil uVision project 18b20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group CORE
    ./: main.c 18b20.c
